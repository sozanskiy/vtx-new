options:
  parameters:
    generate_options: qt_gui
    id: tinysa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: target_freq - offset
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: offset
  id: variable
  parameters:
    comment: test test test test test test
    value: samp_rate/2 - 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 5658e6
  states: {}
- name: vga_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: +offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 4.0e6, 2.0e5, window.WIN_HAMMING, 6.76)
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: float
    vlen: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: target_freq
    fftsize: '4096'
    showports: 'True'
    type: complex
    wintype: window.WIN_FLATTOP
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '27'
    type: fff
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: target_freq + offset
    dev_args: driver=hackrf
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', network_udp_sink_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
